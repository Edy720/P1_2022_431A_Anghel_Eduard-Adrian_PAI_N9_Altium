# Altium project PCB_Proiect_1.PrjPcb
1 sheet, 0 parts. Net scope: global (net labels, ports and power ports of the same name join across sheets).
Board file: PCB1.PcbDoc

## Sheet Sheet1.SchDoc
size A; SheetNumber: 1; SheetTotal: 1